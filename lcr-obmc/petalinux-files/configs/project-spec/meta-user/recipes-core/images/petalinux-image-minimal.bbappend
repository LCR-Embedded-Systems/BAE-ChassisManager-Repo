IMAGE_INSTALL:append = " kernel-module-mdio-netlink"