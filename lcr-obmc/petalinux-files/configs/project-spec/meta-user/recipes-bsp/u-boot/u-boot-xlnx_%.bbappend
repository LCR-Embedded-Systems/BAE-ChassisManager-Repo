FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://platform-top.h file://bsp.cfg"
SRC_URI:append = " file://user_2025-05-04-20-49-00.cfg \
            "
